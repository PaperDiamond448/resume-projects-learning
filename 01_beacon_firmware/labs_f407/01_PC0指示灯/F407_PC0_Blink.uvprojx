# Keil uVision project F407_PC0_Blink.uvprojx, settings and files
target F407_PC0_Blink (6220000::V6.22::ARMCLANG)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(16000000) ELITTLE
  output: F407_PC0_Blink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSI_VALUE=16000000
  c include: .\App;.\Libraries\Device;.\Libraries\CMSIS;.\Libraries\StdPeriph\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./App/: main.c system_clock.c stm32f4xx_conf.h
  group Startup
    ./Startup/: startup_stm32f40_41xxx.s
  group StdPeriph
    ./Libraries/StdPeriph/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
