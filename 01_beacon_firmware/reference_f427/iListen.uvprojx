# Keil uVision project iListen.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: iListen
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F427X,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __CC_ARM, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED =1
  c include: .\USER;.\CORE;.\STM32F4xx\Include;.\STM32F4xx_StdPeriph_Driver\inc;.\DSP_LIB;.\DSP_LIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ./USER/: startup_stm32f427x.s
  group CMSIS
    ./STM32F4xx/Include/: stm32f4xx.h
    ./USER/: stm32f4xx_it.c stm32f4xx_conf.h
    ./STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DSP_LIB
    ./DSP_LIB/: arm_cortexM4lf_math.lib
    ./DSP_LIB/Source/TransformFunctions/: arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c
    ./DSP_LIB/Source/ComplexMathFunctions/: arm_cmplx_mult_cmplx_f32.c
    ./DSP_LIB/Source/StatisticsFunctions/: arm_var_f32.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ./USER/: main.c Gpio.c Nvic.c Timer.c malloc.c hw_config.c IO_operate.c RTC_operate.c ADC_operate.c Comm_operate.c PCLink_operate.c date.c calendar.c iSBL_operate.c FPGA_operate.c ms5837.c iBeaconB_operate.c iBeaconB2_operate.c flash_if.c
software components: CMSIS:CORE 5.3.0
